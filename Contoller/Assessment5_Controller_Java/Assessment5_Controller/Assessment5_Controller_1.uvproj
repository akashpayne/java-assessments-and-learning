# Keil uVision project Assessment5_Controller_1.uvproj, settings and files
target mbed FRDM-K64F (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale Semiconductor
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: Assessment5_Controller_1
  AfterMake: fromelf --bin -o build\Assessment5_Controller_1_K64F.bin build\Assessment5_Controller_1.axf
  c flags: Optim=1
  c define: TARGET_RTOS_M4_M7,  TARGET_FF_ARDUINO,  __CORTEX_M4,  TARGET_KPSDK_MCUS,  TARGET_FRDM,  TARGET_CORTEX_M,  CPU_MK64FN1M0VMD12,  __FPU_PRESENT=1,  TARGET_Freescale,  TARGET_M4,  __MBED__=1,  ARM_MATH_CM4,  TARGET_K64F,  TARGET_KPSDK_CODE,  FSL_RTOS_MBED,  TOOLCHAIN_ARM,  TARGET_MCU_K64F,  TOOLCHAIN_ARM_STD,  MBED_BUILD_TIMESTAMP=1453763526.65,  __ASSERT_MSG,
  c misc: --gnu --no_rtti  --pch --pch_dir=build
  c include: .;  HTTPServer;  HTTPServer/Handler;  C12832;  EthernetInterface;  EthernetInterface/Socket;  EthernetInterface/lwip;  EthernetInterface/lwip/netif;  EthernetInterface/lwip/netif/ppp;  EthernetInterface/lwip/include;  EthernetInterface/lwip/include/netif;  EthernetInterface/lwip/include/lwip;  EthernetInterface/lwip/include/ipv4;  EthernetInterface/lwip/include/ipv4/lwip;  EthernetInterface/lwip/api;  EthernetInterface/lwip/core;  EthernetInterface/lwip/core/snmp;  EthernetInterface/lwip/core/ipv4;  EthernetInterface/lwip-sys;  EthernetInterface/lwip-sys/arch;  EthernetInterface/lwip-eth;  EthernetInterface/lwip-eth/arch;  EthernetInterface/lwip-eth/arch/TARGET_Freescale;  mbed-rtos;  mbed-rtos/rtx;  mbed-rtos/rtx/TARGET_CORTEX_M;  mbed-rtos/rtx/TARGET_CORTEX_M/TARGET_RTOS_M4_M7;  mbed-rtos/rtx/TARGET_CORTEX_M/TARGET_RTOS_M4_M7/TOOLCHAIN_ARM;  mbed-rtos/rtos;  mbed-rpc;  mbed;  mbed/TARGET_K64F;  mbed/TARGET_K64F/TARGET_Freescale;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/common;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/common/phyksz8081;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/drivers;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/drivers/clock;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/drivers/enet;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/drivers/interrupt;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/drivers/pit;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/drivers/pit/common;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/adc;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/can;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/dac;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/dmamux;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/dspi;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/edma;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/enet;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/flextimer;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/gpio;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/i2c;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/llwu;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/lptmr;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/lpuart;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/mcg;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/mpu;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/osc;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/pdb;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/pit;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/pmc;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/port;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/rcm;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/rtc;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/sai;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/sdhc;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/sim;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/smc;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/uart;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/wdog;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/utilities;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_MCU_K64F;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_MCU_K64F/MK64F12;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_MCU_K64F/TARGET_FRDM;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_MCU_K64F/device;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_MCU_K64F/device/MK64F12;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_MCU_K64F/device/device;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_MCU_K64F/device/device/MK64F12;  mbed/TARGET_K64F/TOOLCHAIN_ARM_STD;
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x40000
  scatter file: mbed/TARGET_K64F/TOOLCHAIN_ARM_STD/MK64F.sct
  link misc: mbed/TARGET_K64F/TOOLCHAIN_ARM_STD/board.o
            
              mbed/TARGET_K64F/TOOLCHAIN_ARM_STD/cmsis_nvic.o
            
              mbed/TARGET_K64F/TOOLCHAIN_ARM_STD/mbed_overrides.o
            
              mbed/TARGET_K64F/TOOLCHAIN_ARM_STD/retarget.o
            
              mbed/TARGET_K64F/TOOLCHAIN_ARM_STD/startup_MK64F12.o
            
              mbed/TARGET_K64F/TOOLCHAIN_ARM_STD/sys.o
            
              mbed/TARGET_K64F/TOOLCHAIN_ARM_STD/system_MK64F12.o
            
              mbed/TARGET_K64F/TOOLCHAIN_ARM_STD/mbed.ar
  group src
    mbed-rtos/rtx/TARGET_CORTEX_M/TARGET_RTOS_M4_M7/TOOLCHAIN_ARM/: SVC_Table.S HAL_CM4.c
    EthernetInterface/lwip/netif/: slipif.c etharp.c ethernetif.c
    EthernetInterface/lwip/netif/ppp/: ppp.c vj.c fsm.c randm.c lcp.c auth.c ppp_oe.c pap.c ipcp.c md5.c magic.c chap.c chpms.c
    EthernetInterface/lwip/api/: api_msg.c netbuf.c netifapi.c api_lib.c tcpip.c err.c netdb.c sockets.c
    EthernetInterface/lwip/core/: tcp_in.c netif.c memp.c dns.c pbuf.c dhcp.c raw.c stats.c mem.c udp.c tcp_out.c timers.c init.c tcp.c def.c
    EthernetInterface/lwip/core/snmp/: msg_in.c msg_out.c asn1_dec.c mib_structs.c asn1_enc.c mib2.c
    EthernetInterface/lwip/core/ipv4/: autoip.c inet_chksum.c ip.c icmp.c inet.c ip_addr.c ip_frag.c igmp.c
    EthernetInterface/lwip-sys/arch/: memcpy.c checksum.c sys_arch.c
    EthernetInterface/lwip-eth/arch/TARGET_Freescale/: k64f_emac.c hardware_init_MK64F12.c fsl_enet_driver.c
    mbed-rtos/rtx/TARGET_CORTEX_M/: rt_Task.c rt_System.c rt_List.c rt_Time.c rt_Semaphore.c rt_Mailbox.c rt_CMSIS.c HAL_CM.c rt_Robin.c rt_MemBox.c RTX_Conf_CM.c rt_Event.c rt_Mutex.c
    ./: main.cpp
    HTTPServer/: HTTPConnection.cpp HTTPRequestHandler.cpp HTTPServer.cpp
    HTTPServer/Handler/: FsHandler.cpp RpcHandler.cpp
    C12832/: GraphicsDisplay.cpp C12832.cpp TextDisplay.cpp
    EthernetInterface/: EthernetInterface.cpp
    EthernetInterface/Socket/: UDPSocket.cpp Endpoint.cpp TCPSocketServer.cpp TCPSocketConnection.cpp Socket.cpp
    mbed-rtos/rtos/: Thread.cpp RtosTimer.cpp Semaphore.cpp Mutex.cpp
    mbed-rpc/: parse_pins.cpp RPCFunction.cpp Arguments.cpp rpc.cpp
